.include "yamaha-ca-800-phono.cir"
